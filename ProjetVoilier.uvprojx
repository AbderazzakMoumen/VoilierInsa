# Keil uVision project ProjetVoilier.uvprojx, settings and files
target Simulation (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ProjetVoilier
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include
  asm include: .\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MesSources
    ./Source/: Principale.c
  group MesServices
    ./MesServices/: GIROUETTE.c SERVOMTR.c PLATEAUMTR.c
  group MesDrivers
    ./MesDrivers/: GPIO.c TIMER.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
